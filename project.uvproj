# Keil uVision project project.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  c include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group system_h
    ./system_h/: core_cm3.h LPC17xx.h stdint.h stdio.h stdlib.h string.h system_LPC17xx.h type.h cr_dsplib.h
  group system
    ./system/: startup_LPC17xx.s core_cm3.c system_LPC17xx.c
  group inc
    ./inc/: LPC1768GCZX.h
  group src
    ./src/: project.c sysClock.c sysTick.c pwm.c lpc17xx_gpio.c uart.c tim.c rit.c dma.c dac.c lpc17xx_adc.c fftAnalyse.c lpc_PGA2310.c
  group Documentation
    ./Documentation/: Abstract.txt
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: .\system_h\cr_dsplibFFT_cm3.lib
